options:
  parameters:
    generate_options: qt_gui
    id: EM_Record_10s
    output_language: python
    title: LNA-Free EM Recorder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '49.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e5
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: F:\EM_DATA\baseline\load\cf100MHz_load_b1_60s.cfile
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*60)
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
